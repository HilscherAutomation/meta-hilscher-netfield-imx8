SYSTEMD_AUTO_ENABLE_${PN}_netfield-iolink-edge-gw-revx ?= "enable"
