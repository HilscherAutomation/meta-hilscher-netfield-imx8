# Include required compulab stuff
require compulab-bsp.inc

include linux-common_5.4.inc

