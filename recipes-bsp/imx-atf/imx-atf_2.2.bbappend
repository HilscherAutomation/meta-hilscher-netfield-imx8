COMPATIBLE_MACHINE_niot-e-nfl90-q2n16-n-revx = ".*"
COMPATIBLE_MACHINE_netfield-iolink-edge-gw-revx = ".*"
