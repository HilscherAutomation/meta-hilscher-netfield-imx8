FILESEXTRAPATHS_append := "${THISDIR}/boot-script-fit"
