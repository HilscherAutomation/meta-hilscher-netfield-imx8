# Remove plugins for sensoredge variant
IMAGE_INSTALL:remove:netfield-iolink-edge-gw-revx = " cockpit-onboarding cockpit-docker cockpit-iotedge-docker cockpit-general-settings cockpit-terminal"
