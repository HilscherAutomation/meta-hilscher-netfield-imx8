IMAGE_INSTALL:append:netfield-iolink-edge-gw-revx = " cockpit-branding-netfield-sensoredge"
IMAGE_INSTALL:remove:netfield-iolink-edge-gw-revx = " cockpit-terminal cockpit-docker \
    cockpit-iotedge-docker cockpit-general-settings cockpit-onboarding"
